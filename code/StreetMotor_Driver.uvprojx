# Keil uVision project StreetMotor_Driver.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.2
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: StreetMotor_Driver +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\CMSIS;.\FWLIB\inc;.\FWLIB\src;.\USER;.\BSP;.\LIB;.\DRIVER;.\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group STARTCODE
    ./CMSIS/: startup_stm32f10x_hd.s
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group USER
    ./USER/: main.c stm32f10x_it.c
  group BSP
    ./BSP/: bsp_tim.c bsp_usart.c bsp_led.c bsp_key.c bsp_spi.c
  group LIB
    ./LIB/: pid_lib.c
  group DRIVER
    ./DRIVER/: StreetMotor_driver.c vofa_driver.c oled12864_driver.c
  group APP
    ./APP/: test_app.c
